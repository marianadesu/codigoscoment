options:
  parameters:
    author: Cíntia Porcher
    generate_options: qt_gui
    id: NR_LDPC_backup
    output_language: python
    title: NR_LDPC_backup
  states: {}

blocks:
- name: mod
  id: variable
  parameters:
    value: float(16)
  states: {}
- name: num_bits
  id: variable
  parameters:
    value: '2560'
  states: {}
- name: num_sym
  id: variable
  parameters:
    value: int(num_bits*5/np.log2(mod))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: num_bits
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=4):
              gr.basic_block.__init__(self,
                  name='Demodulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.csingle],
                  out_sig=[np.byte]
              )
              self.M = M

              self.demod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def demodulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.single(message, is_complex=True)
              rxdemod = self.eng.demodulate(message, self.M)
              rxdemod = np.asarray(rxdemod, dtype=np.byte).reshape(-1)
              return rxdemod

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Demodulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  self.demod_message = self.demodulate(in0)
              
              if self.sent_count + len(out) < len(self.demod_message):
                  out[:] = self.demod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.demod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count += out_len

              if self.sent_count >= len(self.demod_message):
                  self.sent_count = 0
                  self.demod_message = None
                  #print(f'Consuming {self.message_len} received bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              #print(f'Sending {out_len} demodulated bits...')

              return out_len
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=4):
              gr.basic_block.__init__(self,
                  name='Demodulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.csingle],
                  out_sig=[np.byte]
              )
              self.M = M

              self.demod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def demodulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.single(message, is_complex=True)
              rxdemod = self.eng.demodulate(message, self.M)
              rxdemod = np.asarray(rxdemod, dtype=np.byte).reshape(-1)
              return rxdemod

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Demodulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  self.demod_message = self.demodulate(in0)
              
              if self.sent_count + len(out) < len(self.demod_message):
                  out[:] = self.demod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.demod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count += out_len

              if self.sent_count >= len(self.demod_message):
                  self.sent_count = 0
                  self.demod_message = None
                  #print(f'Consuming {self.message_len} received bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              #print(f'Sending {out_len} demodulated bits...')

              return out_len
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    F: '0'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, F=0.0, bgn=2.0):        
              self.F = F
              self.bgn = bgn
              
              self.coded_message = None
              self.sent_count = 0

              gr.basic_block.__init__(self,
                  name="Channel Coding (MATLAB)",
                  in_sig=[np.byte],
                  out_sig=[np.byte])

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def encode(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txcoded = self.eng.ch_coder(message, self.F, self.bgn)
              txcoded = np.asarray(txcoded, dtype=np.byte).reshape(-1)
              return txcoded

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Coding ======')

              in0 = input_items[0]
              out = output_items[0]

              # Se não tem mensagem pra enviar, ou se terminou de enviar a mensagem
              if self.sent_count==0:
                  # Coda a mensagem e deixa ela na fila de entrada
                  self.message_len = len(in0)
                  self.coded_message = self.encode(in0)
              
              # Se ainda tem mais do que len(out) bits pra enviar
              if self.sent_count + len(out) < len(self.coded_message):
                  # envia len(out) bits
                  out[:] = self.coded_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else: # Se sobram 0< bits < len(out) bits, (finalzinho da msg), manda os bits que sobraram
                  to_send = self.coded_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              # Vou enviar esse tanto de bits
              self.sent_count+=out_len

              # Se eu enviei todos os bits da mensagem
              if self.sent_count >= len(self.coded_message):
                  # Reseta a contagem de bits
                  self.sent_count = 0
                  self.coded_message = None
                  #print(f'Consuming {self.message_len} uncoded bits...')
                  # Tira a mensagem da fila de entrada SÓ AGORA
                  self.consume(0, self.message_len)
                  self.message_len = 0

              #print(f'Sending {out_len} coded bits...')
              #return produced
              return out_len
    bgn: '2'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    F: '0'
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, F=0.0, bgn=2.0, itrMax=8, out_msgLen=2560):        
              self.F = F
              self.bgn = bgn
              # se colocar fillers bits precisa ajustar a localização deles como entrada
              #self.locs = locs
              self.itrMax = itrMax
              
              self.received_count = 0
              self.sent_count = 0

              if self.bgn == 1:
                  self.coef = 2
              elif self.bgn == 2:
                  self.coef = 5

              self.msg_len = out_msgLen*self.coef 
              self.buffer_out = np.zeros(out_msgLen*self.coef , dtype=np.byte)
              self.decoded_msg = np.zeros(out_msgLen, dtype=np.byte)

              gr.basic_block.__init__(self,
                  name="Channel Decoding (MATLAB)",
                  in_sig=[np.byte],
                  out_sig=[np.byte])

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")
              #print('matlab ok')

          def decode(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              rxdecod = self.eng.ch_decoder(message, self.F, self.bgn, self.itrMax)
              rxdecod = np.asarray(rxdecod, dtype=np.byte).reshape(-1)
              return rxdecod

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Decoding ======')
              in0 = input_items[0]
              out = output_items[0]

              # se ainda não começou a enviar o out
              if self.sent_count == 0:
                  # Se espero receber mais bytes
                  if self.received_count + len(in0) <= self.msg_len:
                      # Popula buffer
                      self.buffer_out[self.received_count:self.received_count+len(in0)] = in0[:]
                      # Incrementa contador de bytes recebidos
                      self.received_count += len(in0)
                  
                  if self.received_count != self.msg_len:
                      #print(f'Consuming {len(in0)} coded bits...')
                      self.consume(0, len(in0))
                  
                  # se já recebi todos os bytes, decodifica e começa a transissão
                  if self.received_count == self.msg_len:
                      self.received_count = 0
                      #print('Decoding...')
                      self.decoded_msg[:] = self.decode(self.buffer_out)

                      out[:] = self.decoded_msg[:len(out)]
                      self.sent_count += len(out)
                      #print(f'Sendin: {self.sent_count} uncoded bits...')

                      return len(out)
                  else:
                      return 0

              # se a transmissão já foi iniciada, sent_count != 0
              else:
                  if self.sent_count + len(out) < len(self.decoded_msg):
                      out[:] = self.decoded_msg[self.sent_count : self.sent_count + len(out)]
                      self.sent_count += len(out)
                  # se len(out) é maior que o restante da mensagem
                  else:
                      out[:len(self.decoded_msg)-self.sent_count] = self.decoded_msg[self.sent_count:]
                      self.sent_count += len(self.decoded_msg) - self.sent_count
                  
                  #print(f'Sending {self.sent_count} uncoded bits...')
                  
                  if self.sent_count == len(self.decoded_msg):
                      #print(f'Consuming {len(in0)} coded bits...')
                      self.consume(0, len(in0))

                  return len(out)
    bgn: '2'
    itrMax: '6'
    out_msgLen: num_bits
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Coded BER (PYTHON)',   # will show up in GRC
                  in_sig=[np.byte, np.byte],
                  out_sig=[np.float32]
              )

              self.bit_count = 0
              self.error_count = 0

          def general_work(self, input_items, output_items):
              #buffer references
              print('====== BER ======')
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]

              print(f'(BER) Original size: {len(in0)}, Received size: {len(in1)}')

              inlen = min([len(in0), len(in1)])

              in0_use = in0[:inlen]
              in1_use = in1[:inlen]

              self.bit_count += inlen
              self.error_count += np.sum(in0_use^in1_use)

              print(f'{self.error_count} errors in {self.bit_count} bits...')

              self.consume(0, inlen)
              self.consume(1, inlen)

              out[0] = self.error_count/self.bit_count

              print(f'Coded BER: {out[0]*100:.6f}%')

              return 1
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Uncoded BER (PYTHON)',   # will show up in GRC
                  in_sig=[np.byte, np.byte],
                  out_sig=[np.float32]
              )

              self.bit_count = 0
              self.error_count = 0

          def general_work(self, input_items, output_items):
              #buffer references
              print('====== BER ======')
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]

              print(f'(BER) Original size: {len(in0)}, Received size: {len(in1)}')

              inlen = min([len(in0), len(in1)])

              in0_use = in0[:inlen]
              in1_use = in1[:inlen]

              self.bit_count += inlen
              self.error_count += np.sum(in0_use^in1_use)

              print(f'{self.error_count} errors in {self.bit_count} bits...')

              self.consume(0, inlen)
              self.consume(1, inlen)

              out[0] = self.error_count/self.bit_count

              print(f'Uncoded BER: {out[0]*100:.6f}%')

              return 1
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=4):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(self,
                  name='Modulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.csingle]
              )
              self.M = M

              self.mod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def modulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txmod = self.eng.modulate(message, self.M)
              txmod = np.asarray(txmod, dtype=np.csingle).reshape(-1)
              return txmod

          def general_work(self, input_items, output_items):
              #buffer references
              print('====== Modulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  self.mod_message = self.modulate(in0)
              
              if self.sent_count + len(out) < len(self.mod_message):
                  out[:] = self.mod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.mod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count+=out_len

              if self.sent_count >= len(self.mod_message):
                  self.sent_count = 0
                  self.mod_message = None
                  print(f'Consuming {self.message_len} coded bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              print(f'Sending {out_len} modulated bits...')
              #return produced
              return out_len
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=4):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(self,
                  name='Modulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.csingle]
              )
              self.M = M

              self.mod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def modulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txmod = self.eng.modulate(message, self.M)
              txmod = np.asarray(txmod, dtype=np.csingle).reshape(-1)
              return txmod

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Modulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  self.mod_message = self.modulate(in0)
              
              if self.sent_count + len(out) < len(self.mod_message):
                  out[:] = self.mod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.mod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count+=out_len

              if self.sent_count >= len(self.mod_message):
                  self.sent_count = 0
                  self.mod_message = None
                  #print(f'Consuming {self.message_len} coded bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              #print(f'Sending {out_len} modulated bits...')
              #return produced
              return out_len
  states: {}
- name: epy_block_4_0_0
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=4):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(self,
                  name='Modulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.csingle]
              )
              self.M = M

              self.mod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def modulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txmod = self.eng.modulate(message, self.M)
              txmod = np.asarray(txmod, dtype=np.csingle).reshape(-1)
              return txmod

          def general_work(self, input_items, output_items):
              #buffer references
              #print('====== Modulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  self.mod_message = self.modulate(in0)
              
              if self.sent_count + len(out) < len(self.mod_message):
                  out[:] = self.mod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.mod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count+=out_len

              if self.sent_count >= len(self.mod_message):
                  self.sent_count = 0
                  self.mod_message = None
                  #print(f'Consuming {self.message_len} coded bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              #print(f'Sending {out_len} modulated bits...')
              #return produced
              return out_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Tx
    label2: Rx
    nconnections: '2'
    size: num_sym
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Tx_unc
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Rx
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Rx_unc
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: in_sig
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: out_sig
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: out_sig_unc
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Tx_unc
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Rx
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Rx
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: Rx_unc
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: in_sig
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: in_sig
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: out_sig
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: out_sig_unc
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_random_source_x_0_0, '0', epy_block_4_0_0, '0']
- [analog_random_source_x_0_0, '0', virtual_sink_2, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_1_0, '0']
- [blocks_throttle_0_0, '0', epy_block_1_0, '0']
- [epy_block_0_0, '0', epy_block_2_0, '0']
- [epy_block_0_0_0, '0', virtual_sink_3_0, '0']
- [epy_block_1_0, '0', epy_block_4, '0']
- [epy_block_1_0, '0', epy_block_4_0, '0']
- [epy_block_2_0, '0', virtual_sink_3, '0']
- [epy_block_3, '0', blocks_null_sink_0, '0']
- [epy_block_3_0, '0', blocks_null_sink_0_0, '0']
- [epy_block_4, '0', virtual_sink_0, '0']
- [epy_block_4_0, '0', virtual_sink_0, '0']
- [epy_block_4_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0, '1']
- [virtual_source_0_1, '0', blocks_add_xx_0_0, '1']
- [virtual_source_1, '0', epy_block_0_0, '0']
- [virtual_source_1_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_1_1, '0', epy_block_0_0_0, '0']
- [virtual_source_2, '0', epy_block_3, '0']
- [virtual_source_2_0, '0', epy_block_3_0, '0']
- [virtual_source_3, '0', epy_block_3, '1']
- [virtual_source_3_0, '0', epy_block_3_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
