options:
  parameters:
    author: Cíntia
    generate_options: qt_gui
    id: NR_LDPC_files
    output_language: python
    title: NR_LDPC_files
  states: {}

blocks:
- name: mod
  id: variable
  parameters:
    value: float(4)
  states: {}
- name: num_bits
  id: variable
  parameters:
    value: int(2560)
  states: {}
- name: num_sym
  id: variable
  parameters:
    value: int(12800/np.log2(mod))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: num_bits
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Tx_QPSK_ldpc
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: original_msg_ldpc
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: coded_msg_ldpc
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    F: '0'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, F=0.0, bgn=2.0):        
              self.F = F
              self.bgn = bgn
              
              self.coded_message = None
              self.sent_count = 0

              gr.basic_block.__init__(self,
                  name="Channel Coding (MATLAB)",
                  in_sig=[np.byte],
                  out_sig=[np.byte])

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def encode(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txcoded = self.eng.ch_coder(message, self.F, self.bgn)
              txcoded = np.asarray(txcoded, dtype=np.byte).reshape(-1)
              return txcoded

          def general_work(self, input_items, output_items):
              #buffer references
              print('====== Coding ======')

              in0 = input_items[0]
              out = output_items[0]

              print(f'bits in: {in0[:10]}')

              # Se não tem mensagem pra enviar, ou se terminou de enviar a mensagem
              if self.sent_count==0:
                  # Coda a mensagem e deixa ela na fila de entrada
                  self.message_len = len(in0)
                  self.coded_message = self.encode(in0)
              
              # Se ainda tem mais do que len(out) bits pra enviar
              if self.sent_count + len(out) < len(self.coded_message):
                  # envia len(out) bits
                  out[:] = self.coded_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else: # Se sobram 0< bits < len(out) bits, (finalzinho da msg), manda os bits que sobraram
                  to_send = self.coded_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              # Vou enviar esse tanto de bits
              self.sent_count+=out_len

              # Se eu enviei todos os bits da mensagem
              if self.sent_count >= len(self.coded_message):
                  # Reseta a contagem de bits
                  self.sent_count = 0
                  self.coded_message = None
                  print(f'Consuming {self.message_len} uncoded bits...')
                  # Tira a mensagem da fila de entrada SÓ AGORA
                  self.consume(0, self.message_len)
                  self.message_len = 0
              
              print(f'bits out: {out[:10]}')
              print(f'Sending {out_len} coded bits...')
              #return produced
              return out_len
    bgn: '2'
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    M: mod
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import matlab.engine
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, M=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(self,
                  name='Modulation (MATLAB)',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.csingle]
              )
              self.M = M

              self.mod_message = None
              self.sent_count=0

              self.eng = matlab.engine.start_matlab()
              self.eng.cd(r"G:\Meu Drive\UFRGS\PD\MATLABcodes\MATLABcoder")

          def modulate(self, message):
              message = np.reshape(message,(-1,1))
              message = matlab.int8(message)
              txmod = self.eng.modulate(message, self.M)
              txmod = np.asarray(txmod, dtype=np.csingle).reshape(-1)
              return txmod

          def general_work(self, input_items, output_items):
              #buffer references
              print('====== Modulating ======')
              in0 = input_items[0]
              out = output_items[0]

              if self.sent_count==0:
                  self.message_len = len(in0)
                  #self.mod_message = self.modulate(in0)
                  self.mod_message = self.modulate(np.reshape(in0,(-1,1)))
              
              if self.sent_count + len(out) < len(self.mod_message):
                  out[:] = self.mod_message[self.sent_count:self.sent_count+len(out)]
                  out_len = len(out)
              else:
                  to_send = self.mod_message[self.sent_count:]
                  out_len = len(to_send)
                  out[:out_len] = to_send
              
              self.sent_count+=out_len

              if self.sent_count >= len(self.mod_message):
                  self.sent_count = 0
                  self.mod_message = None
                  print(f'Consuming {self.message_len} coded bits...')
                  self.consume(0, self.message_len)
                  self.message_len = 0

              print(f'Sending {out_len} modulated bits...')
              #return produced
              return out_len
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: num_sym
    type: complex
  states: {}

connections:
- [analog_random_source_x_0_0, '0', blocks_file_sink_0_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', epy_block_1_0, '0']
- [epy_block_1_0, '0', blocks_file_sink_0_1, '0']
- [epy_block_1_0, '0', epy_block_4_0, '0']
- [epy_block_4_0, '0', blocks_file_sink_0, '0']
- [epy_block_4_0, '0', qtgui_const_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
