options:
  parameters:
    author: Cíntia
    generate_options: qt_gui
    id: PD_LTE_CONV_USRP
    output_language: python
    title: LTE_Conv_USRP
  states: {}

blocks:
- name: RF_gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 100e3
    step: '1'
    stop: 60e6
    value: 1e6
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 750e6
    step: 1e3
    stop: 3500e6
    value: 900e6
  states: {}
- name: mod
  id: variable
  parameters:
    value: float(4)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_bits
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: num_sym
  id: variable
  parameters:
    value: int(num_bits*3/np.log2(mod))
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: rrc_the
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, samp_rate, samp_rate/sps, eb, 100)
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 200e3
    step: '1'
    stop: 60e6
    value: bandwidth*2
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: 'Time: BW'
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: Rx_QPSK_conv_sync
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: Rx_QPSK_conv_usrp
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: Tx_QPSK_conv
    repeat: 'True'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28/100.0
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps*1.00
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_the
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0_0_0_1_0_1_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"Dark Blue"'
    grid: 'True'
    label1: Rx
    label2: Rx PLL
    nconnections: '2'
    size: num_sym
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0_1_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"Dark Blue"'
    grid: 'True'
    label1: Rx
    size: num_sym
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bandwidth
    center_freq0: frequency
    dev_addr: '"serial=F4B621"'
    gain0: RF_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: frequency
    dev_addr: '"serial=F4B628"'
    gain0: RF_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Sync_out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: PLL_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Sync_out
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: PLL_out
  states: {}

connections:
- [blocks_file_source_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0_0_0_1_0_1_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0_0_0_1_0_1_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0_0_1_0_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
